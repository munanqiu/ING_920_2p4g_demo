# Keil uVision project ing_920_2p4g_mini_source_900.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING2000 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x2000000-0x2200000) IRAM(0x20000000-0x20008000)
  output: ing_920_2p4g_mini_source_900 +hex
  AfterMake: fromelf.exe --bin -o ing_920_2p4g_mini_source_900.bin ./output/ing_920_2p4g_mini_source_900.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: sdk/bundles/mini/inc;sdk/bundles/mini/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing20;sdk/src/Tools;sdk/src
  library: MicroLIB
  memory RVCT4: ROM 33734656 size 81920
  memory RVCT9: RAM 536884848 size 35216
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing2000.s
    sdk/bundles/mini/ING20xx/: symdefs.m
  group BSP
    sdk/src/BSP/: eflash.c
  group FWlib
    sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
  group Tools
    sdk/src/Tools/: trace.c
