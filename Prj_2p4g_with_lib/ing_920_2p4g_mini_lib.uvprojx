# Keil uVision project ing_920_2p4g_mini_lib.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: ING92000 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M3") CLOCK(12800000) ELITTLE
  output: ing_920_2p4g_mini_lib +hex
  AfterMake: fromelf.exe --bin -o ing_920_2p4g_mini_lib.bin ./output/ing_920_2p4g_mini_lib.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: sdk/bundles/mini/inc;sdk/bundles/mini/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing920;sdk/src/Tools;sdk/src;.\src;..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x202c000 size 0x54000
  memory RVCT9: RAM 0x20003670 size 0x8990
  scatter file: .\src\ing_920_2p4g_mini_source.sct
  group APP
    ./src/: main.c profile.c uart_console.c app_2p4g.c
  group StartUP
    ./src/: startup_ing92000.s
    sdk/bundles/mini/ING9208xx/: symdefs.m
  group BSP
    sdk/src/BSP/: eflash.c
  group FWlib
    sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
  group Tools
    sdk/src/Tools/: trace.c
  group 2P4G
    ../lib/: ing_2p4g_920.lib
software components: CMSIS:CORE 4.3.0
