# Keil uVision project prj_2p4g_ROM_with_source.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: ING2000 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M3") CLOCK(12800000) ELITTLE
  output: prj_2p4g_ROM_with_source +hex
  AfterMake: fromelf.exe --bin -o prj_2p4g_ROM_with_source.bin ./output/prj_2p4g_ROM_with_source.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: sdk/bundles/rom/inc;sdk/bundles/rom/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing20;sdk/src/Tools;sdk/src;..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x2004000 size 0x3c000
  memory RVCT9: RAM 0x20004408 size 0x7bf8
  scatter file: .\src\ing_920_2p4g_mini_source.sct
  group APP
    ./src/: main.c profile.c app_2p4g.c uart_console.c
  group StartUP
    ./src/: startup_ing2000.s
    sdk/bundles/rom/ING20xx/: symdefs.m
  group BSP
    sdk/src/BSP/: eflash.c
  group FWlib
    sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
  group Tools
    sdk/src/Tools/: trace.c
  group 2P4G
    ../lib/: ing_2p4g_920_ROM.lib
software components: CMSIS:CORE 4.3.0
